# Keil uVision project IAP.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAP
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USR\libraries\OnChip\SerialPort;..\USR\libraries\System\Interrupt;..\USR\libraries\ToolBox\IAP;..\USR\libraries\System\TaskManager;..\USR\libraries\ToolBox\Buffer;..\USR\libraries\ToolBox\GidLink;..\USR\libraries\System;..\USR\libraries\OffChip\LED
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group OnChip
    ../USR/libraries/OnChip/SerialPort/: USART.cpp
    ../USR/libraries/ToolBox/Buffer/: FIFOBuffer.h DataFrame.h
    ../USR/libraries/ToolBox/GidLink/: GidLink.cpp GidLink.h
    ../USR/libraries/ToolBox/IAP/: IAP.cpp IAP.h
    ../USR/libraries/System/Interrupt/: Interrupt.cpp Interrupt.h
    ../USR/libraries/System/TaskManager/: TaskManager.cpp TaskManager.h
    ../USR/libraries/System/: Configuration.h
    ../USR/libraries/OffChip/LED/: LED.cpp
  group New Group
    ./: main.cpp
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
