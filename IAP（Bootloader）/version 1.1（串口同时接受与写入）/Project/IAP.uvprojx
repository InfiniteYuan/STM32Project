# Keil uVision project IAP.uvprojx, settings and files
target APP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAP +hex
  AfterMake: B:\Keil_v5\ARM\ARMCC\bin\fromelf.exe   --bin -o  D:\Study\STM32\IAP\Project\version_1.1\Project\Out\IAP.bin D:\Study\STM32\IAP\Project\version_1.1\Project\Out\IAP.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c
  group IAP
    ../USER/: IAP.c
  group SYSTEM
    ../USER/: SYS.c delay.c
  group HardWare
    ../USER/: LED.c Key.c USART.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
