# Keil uVision project GPIO_Systick.uvprojx, settings and files
target GPIO_Systick (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_Systick +hex
  AfterMake: B:\Keil_v5\ARM\ARMCC\bin\fromelf.exe   --bin -o  D:\Study\实验室\远程控制平台\Project\APP\GPIO&Systick\Project\Objects\GPIO_Systick.bin D:\Study\实验室\远程控制平台\Project\APP\GPIO&Systick\Project\Objects\GPIO_Systick.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USR;.\RTE;.\RTE\Device;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8008000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USR
    ../USR/: main.c pData.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
