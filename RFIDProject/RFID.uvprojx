# Keil uVision project RFID.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RFID
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\libraries\OnChip\SerialPort;.\libraries\OnChip\Timer;.\libraries\ToolBox\Buffer;.\libraries\ToolBox\GidLink;.\libraries\System\Interrupt;.\libraries\System\TaskManager;.\libraries\System;.\libraries\ToolBox\IAP;.\libraries\OffChip\ESP8266;.\libraries\OffChip\LED;.\libraries\OnChip\SPI;.\libraries\OnChip\GPIO;.\libraries\OffChip\MFRC522
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group OnChip
    ./libraries/OnChip/SerialPort/: USART.cpp
    ./libraries/OnChip/Timer/: Timer.cpp
    ./libraries/OnChip/SPI/: SPI.cpp
    ./libraries/OnChip/GPIO/: GPIO.cpp
  group ToolBox
    ./libraries/ToolBox/GidLink/: GidLink.cpp
    ./libraries/ToolBox/IAP/: IAP.cpp
    ./libraries/System/TaskManager/: TaskManager.cpp
    ./libraries/System/Interrupt/: Interrupt.cpp
  group APP
    ./: main.cpp
  group OffChip
    ./libraries/OffChip/ESP8266/: esp8266.cpp Socket_esp8266.cpp
    ./libraries/OffChip/LED/: LED.cpp
    ./libraries/OffChip/MFRC522/: MFRC522.cpp
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
