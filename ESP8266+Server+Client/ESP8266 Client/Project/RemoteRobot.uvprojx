# Keil uVision project RemoteRobot.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RemoteRobot +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\lib\inc;..\USR\System;..\USR;.\RTE;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group OnChip
    ../lib/src/: F103_PWM.cpp GPIO.cpp USART.cpp Timer.cpp LED.cpp
  group OffChip
    ../lib/src/: Socket_esp8266.cpp esp8266.cpp
  group System
    ../USR/: Interrupt.cpp hardware.cpp
  group App
    ../USR/: main.cpp app.cpp protocol.cpp
  group ToolBox
    ../lib/src/: TaskManager.cpp
    ../USR/: CRC.cpp
software components: CMSIS:CORE 4.3.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
